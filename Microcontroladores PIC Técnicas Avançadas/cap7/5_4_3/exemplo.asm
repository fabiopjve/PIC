LIST 	P=16F627
INCLUDE <P16F627.INC>
__CONFIG _CP_OFF & _WDT_OFF & _PWRTE_OFF & _BODEN_OFF & _MCLRE_OFF & _INTRC_OSC_NOCLKOUT & _LVP_OFF
A0	EQU 0x20
B0	EQU 0x21
TEMP1	EQU 0x22
TEMP2	EQU 0x23
TEMP3	EQU 0x24
ORG	0x0000
	GOTO	INICIO
DIV8_8:
	MOVLW	0x08
 	MOVWF	TEMP1
	CLRF	TEMP2
	MOVF	A0,W
	MOVWF	TEMP3 
DIV8_8_LOOP:
	BCF	STATUS,C
	BTFSC	TEMP3,7
	BSF	STATUS,C
	RLF	TEMP2,F
	MOVF	B0,W
	SUBWF	TEMP2,F
	BTFSC	STATUS,C
	GOTO	DIV8_8_PTA
	ADDWF	TEMP2,F
	BCF	STATUS,C
DIV8_8_PTA:
	RLF	TEMP3,F
	DECFSZ	TEMP1,F
	GOTO	DIV8_8_LOOP
	MOVF	TEMP3,W
	RETURN
INICIO:
	MOVLW	D'199'		;
	MOVWF	A0		; Dividendo (A0) = 199 decimal
	MOVLW	D'23'		;
	MOVWF	B0		; Divisor (B0) = 23 decimal
	CALL	DIV8_8		; chamada da sub-rotina
	SLEEP
END
; resultado: W=0x08, Z=’0’, DC=’0’ e C=’1’. 199/23=8,65...
